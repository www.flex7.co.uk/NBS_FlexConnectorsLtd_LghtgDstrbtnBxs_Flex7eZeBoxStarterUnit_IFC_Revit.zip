Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2016-03-17T11:49:52
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20131024_2115(x64) - Exporter 3.13.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Mar 17 11:49:52 2016* Host: NCL-PI07* Database: C:\Users\MorrenA\AppData\Local\Temp\{E8B181AB-531E-453E-9E38-09FFC45398E1}\ifc* Database version: 5507* Database creation date: Thu Mar 17 11:49:51 2016* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Mar 17 11:49:52 2016* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Mar 17 11:49:52 2016* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: NBS_FlexConnectorsLtd_LghtgDstrbtnBxs_Flex7eZeBoxStarterUnit, NBS_FlexConnectorsLtd_LghtgDstrbtnBxs_Flex7eZeBoxStarterUnit:NBS_FlexConnectorsLtd_LghtgDstrbtnBxs_Flex7eZeBoxStarterUnit:237379
In: Level 0
Type - Classification: Pr_70_70_47_46 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FlexConnectorsLtd_LightingDistributionBoxes_Flex7eZeBoxStarterUnit_2Way; ManufacturerName: Flex Connectors Ltd; ManufacturerURL: www.flexconnectors.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/pk32uifv; NBSDescription: Lighting distribution boxes; NBSReference: 90-50-45/380; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSTypeID: n/a; ProductInformation: www.flexconnectors.co.uk/products/power-up/starter-units; Revision: n/a; Uniclass2015Version: Products v1.4; Version: 3; Uniclass2015Title: Lighting distribution boxes; Uniclass2015Code: Pr_70_70_47_46
Type - NBS_Data - CableEntry: n/a; Conductors: 3 x 2.5 mm², 2 x 4.0 mm² or 1 x 6.0 mm²; ConnectorsPowerInputConnection: Cage type terminals to accept circuit conductors; ConnectorsPowerOutputConnectorType: Fully shrouded female connector; DistributionBox: Anodised aluminium extrusion with PA6 UL94 V-0 rated sockets; OutgoingConnectionsPoles: 7; OutgoingConnectionsQuantity: 2; Rating: 16 A; Standards: To BS 5733
Type - Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 0 W; HasProtectiveEarth: yes; InsulationStandardClass: Class1Appliance; IPCode: IP20; NominalCurrent: 16 A; NominalFrequencyRange: 50.0, 60.0; NominalVoltage: 230.0 , 230.0; NumberOfPoles: 7; PhaseAngle: 0 deg; PhaseReference: n/a; UsageCurrent: 0 A
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_70_47_46:Lighting distribution boxes; CodePerformance: LVD-2006/95/EC; Color: Silver, Black; Constituents: n/a; Description: The flex7 eZeBox Starter Unit provides a plug-in connection of multiple luminaires controlled by a single switch or control device; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: info@flexconnectors.co.uk; Material: Anodised Aluminium, Nylon - PA6 UL94 V-0 rated; ModelNumber: fsu02; ModelReference: flex7 eZeBox Starter Unit; Name: LightingDistributionBoxes_Flex7eZeBoxStarterUnit_2Way_FlexConnectorsLtd; NominalHeight: 48.7 mm; NominalLength: 425.2 mm; NominalWidth: 89.4 mm; ReplacementCost: n/a; Shape: Rectangular cuboid; Size: 175.2 x 89.4 x 48.7; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
